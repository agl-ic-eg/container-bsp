DEPENDS_remove = " mmngr-user-module linux-renesas "

EXTRA_OECONF_remove = "--enable-kms"
PACKAGECONFIG_remove = "kms"
